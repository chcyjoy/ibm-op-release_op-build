## openpower/package/raid-util/Config.in
```kconfig
config BR2_PACKAGE_RAID_UTIL
        bool "raid_util"
        help
            Broadcom MegaRAID StorCLI RAID tool
```
